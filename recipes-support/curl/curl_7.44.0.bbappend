PACKAGECONFIG_append_class-target = " libssh2 gnutls"
