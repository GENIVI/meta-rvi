require rvi.inc

SRC_URI = "git://github.com/GENIVI/rvi_core;branch=release-0.5.0;name=rvi;protocol=https"
SRCREV_rvi = "0b3e9d1d42a92bb349acab7b7131d9ccae391076"

PV = "0.5.0"

PR = "${INC_PR}.0"
